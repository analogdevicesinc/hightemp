# Keil uVision project ht_dab_va108xx-ULINK2_FLASH.uvprojx, settings and files
target ht_dab_va108xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: VA108xx Generic
  pack: Vorago.VA108xx.1.4.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ht_dab_va108xx +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin #L --output $L@L.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: RTT_LOG, SKIP_UTILS
  c include: ..\..\Driver\hdr;.\hdr;..\..\Utilities\hdr;..\..\Common\hdr;.\Source\include;.\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group common
    ../../common/hdr/: cmsis_armcc.h core_cm0.h core_cmFunc.h core_cmInstr.h system_va108xx.h va108xx.h
    ../../common/src/: startup_va108xx.s system_va108xx.c
  group driver
    ../../driver/hdr/: driver_common.h
    ../../driver/src/: driver.common.c
  group app
    ./src/: main.c uart.c output.c parser.c sampling_engine.c
  group FreeRTOS
    ./Source/: list.c queue.c tasks.c timers.c
    ./Source/portable/RVDS/ARM_CM0/: port.c
    ./Source/portable/MemMang/: heap_1.c
